## src/modules/rover_lawnmower/Kconfig
```kconfig
menuconfig MODULES_ROVER_LAWNMOWER
	bool "rover_lawnmower"
	default n
	---help---
		Enable support for lawnmower rover
```
